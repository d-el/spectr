# IAR project sps.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x4 ST STM32F100x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: CM3\DeviceSupport\ST\STM32F10x; CM3\CoreSupport; drivers\inc; TSK\inc; FreeRTOS\include; Lib; Code\inc; DebFiles
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: FreeRTOS\include
  OBJCOPY.OOCOutputFile: sps.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    CM3/CoreSupport/: core_cm3.c
    CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_ld_vl.s
    CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CODE
    Code/src/: crc.c main.c OSinit.c specificMath.c
  group DEBUG
    DebFiles/: timeMeas.c
  group DRIVERS
    drivers/src/: adc.c drivers.c gpio.c initPeripheral.c owSlave.c uart.c
  group FreeRTOS
    FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c portasm.s queue.c tasks.c
    FreeRTOS/include/: FreeRTOSConfig.h
  group LIB
    Lib/: IQmathLib-cm3.a
  group TSK
    TSK/src/: adcTSK.c display.c systemTSK.c uartTSK.c
