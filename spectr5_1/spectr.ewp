# IAR project spectr.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100RB ST STM32F100RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: CM3\DeviceSupport\ST\STM32F10x; CM3\CoreSupport; drivers\inc; TSK\inc; PeriodicFunction\inc; FreeRTOS\include; Lib; prmSystem; Code\inc; DebFiles
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: FreeRTOS\include
  OBJCOPY.OOCOutputFile: spectr.hex
  prebuild: wscript.exe otherFiles\versionGen.vbs Code\src\version.c Code\inc\version.h
  ILINK.IlinkOutputFile: spectr.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    CM3/CoreSupport/: core_cm3.c
    CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
    CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CODE
    Code/src/: bubbles.c crc.c cube3d.c fonts.c graphics.c image.c main.c OSinit.c setting.c specificMath.c spsPF.c temperaturePF.c version.c
  group DEBUG
    DebFiles/: timeMeas.c
  group DRIVERS
    drivers/src/: adc.c beep.c delay.c drivers.c ds18b20.c enco.c flash.c gpio.c initPeripheral.c key.c LPH8731.c onewire.c spsControl.c uart.c
    drivers/inc/: spsControl.h
  group FreeRTOS
    FreeRTOS/src/: croutine.c event_groups.c heap_2.c list.c port.c portasm.s queue.c tasks.c timers.c
    FreeRTOS/include/: FreeRTOSConfig.h
  group LIB
    Lib/: IQmathLib-cm3.a
  group PrmSystem/ModBus
    prmSystem/: MakeOpis.c Menu_struct.c ModbusSlave.c
  group TSK
    TSK/src/: adcTSK.c baseTSK.c chargeTSK.c scopeTSK.c systemTSK.c uartTSK.c
